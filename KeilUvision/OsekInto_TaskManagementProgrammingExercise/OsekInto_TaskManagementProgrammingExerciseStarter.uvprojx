# Keil uVision project OsekInto_TaskManagementProgrammingExerciseStarter.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OsekIntro_Example1
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\oil;..\..\OsekLib;..\OsekInto_ResourceManagementProgrammingExercise
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../../oil/: OsCfg.c OsCfg.h
    ../../OsekLib/: counter.c counter.h os.h OsTypes.h hook.c OsekLib.lib
    ../../OsekLib/startup/: keilUvisoin_startup.s
    ./: gpio.h tm4c123gh6pm.h sysctl.h driverlib.lib hw_memmap.h OsekInto_TaskManagementProgrammingExerciseStarter.c SWTimer.c SWTimer.h OSCallbacks.c
software components: CMSIS:CORE 5.4.0
